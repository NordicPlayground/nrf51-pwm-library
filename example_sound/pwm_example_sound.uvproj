# Keil uVision project pwm_example_sound.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: pwm_example_sound +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../../../../Source/: keil_arm_uv4.lnt
    ../: nrf_pwm.c main_sound.c
  group core
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../Source/templates/: system_nrf51.c
target nRF51822_S110 (ARM-ADS)
  device: nRF51 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: template_project_arm_s110 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x2000
